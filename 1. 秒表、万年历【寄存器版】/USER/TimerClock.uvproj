# Keil uVision project TimerClock.uvproj, settings and files
target ClockTimer (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TimerClock +hex
  c flags: Optim=1
  c include: ..\HAEDWARE\key;..\HAEDWARE\led;..\HAEDWARE\timer;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group HardWare
    ../HAEDWARE/key/: key.c
    ../HAEDWARE/led/: led.c
    ../HAEDWARE/timer/: timer.c
  group System
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group User
    ./: main.c STM32F10x.s
